Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Номер проекта
Time: 2018-08-31T10:20:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.0.490.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 31 10:20:32 2018 * Host: 43-120 * Database: C:\Users\I247A~1.VOI\AppData\Local\Temp\{6F53400F-9C2D-4EE5-A571-A026256CF171}\ifc * Database version: 5507 * Database creation date: Fri Aug 31 10:20:31 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 31 10:20:32 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 31 10:20:32 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 45, 25, 90026; RefLongitude: 37, 36, 54, 74707; RefElevation: 0 mm
Прочее - Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Категория: Сведения о проекте; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Прочее - Категория: Сведения о проекте; Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Верхний брус 8 мм; Семейство: Уровень: Верхний брус 8 мм; Семейство и типоразмер: Уровень: Верхний брус 8 мм; Тип: Уровень: Верхний брус 8 мм
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Уровень 1; Несущие конструкции: no; Построение этажа: yes; Имя типа: Верхний брус 8 мм
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: Заголовок уровня - Окружность: Заголовок уровня - Окружность; Образец линий: Центр; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: no; Цвет: 0

# IfcRailing: Ограждение:ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11, Ограждение:ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11:269290
In: Уровень 1
Classification: ﻿﻿ ​ ​ ﻿ ﻿ ﻿ ​ ﻿ ​ ​ ﻿​ ﻿ ﻿ ﻿​ ﻿ ﻿ ​ ﻿ ﻿﻿ (Uniformat); Material: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11
Pset_RailingCommon - Reference: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ROLS ISOMARKET
Зависимости - Базовый уровень: Уровень: Уровень 1; Смещение проступи/тетивы: 0 mm; Смещение снизу: 0 mm
Идентификация - Вариант конструкции: Главная модель; Комментарии: ﻿﻿ ​ ​ ﻿ ﻿ ﻿ ​ ﻿ ​ ​ ﻿​ ﻿ ﻿ ﻿​ ﻿ ﻿ ​ ﻿ ﻿﻿; BIM library: https://bimlib.ru/manufacturer/rols-isomarket/1769/; URL: http://www.rols-isomarket.ru/catalog/aksessuary/lenta-dempfernaya-energofloor/; Группа модели: Лента демпферная Energofloor 10/0,15-11; Изготовитель: ROLS ISOMARKET; Имя типа: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; Ключевая пометка: ﻿﻿ ​ ​ ﻿ ﻿ ﻿ ​ ﻿ ​ ​ ﻿​ ﻿ ﻿ ﻿​ ﻿ ﻿ ​ ﻿ ﻿﻿; Код по классификатору: ﻿﻿ ​ ​ ﻿ ﻿ ﻿ ​ ﻿ ​ ​ ﻿​ ﻿ ﻿ ﻿​ ﻿ ﻿ ​ ﻿ ﻿﻿; Комментарии к типоразмеру: EFRL1015011DM; Описание: Лента демпферная Energofloor предназначена для компенсации температурного расширения цементной стяжки в системах отопления типа «тёплый пол».; Разработано: support@bimlib.ru
Прочее - Категория: Ограждение; Код типа: Ограждение: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; Семейство: Ограждение: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; Семейство и типоразмер: Ограждение: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; Тип: Ограждение: ROLS_ISOMARKET_Лента демпферная Energofloor 10/0,15-11; Имя семейства: Ограждение
Размеры - Длина: 3000 mm
Стадии - Стадия возведения: Новая конструкция
Верхний поручень - Высота: 0 mm
Перила 1 - Расположение: Нет
Перила 2 - Положение: Нет
Строительство - Высота ограждения: 150 mm; Изменение высоты на площадках: 0 mm; Смещение балясин: 0 mm; Соединения ограждений: Обрезка; Соединения под углом: Добавление верт/гор сегментов; Соединения по касательной: Удлинение поручней; С подстройкой высоты на площадках: Нет
